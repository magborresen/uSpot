# Repository magborresen/uSpot

## KiCad design µSpot.kicad_pcb

Parts:
BAT+1: Conn_01x01; MountingHole_4.3mm_M4_Pad_Via
BAT-1: Conn_01x01; MountingHole_4.3mm_M4_Pad_Via
C1, C5: 22uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4: 22uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C6: 0.1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C9: 3.3u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1: Red; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D2: 2SS100L-W; D_SOD-123F
D3: Blue; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
H1, H2: MountingHole; MountingHole_2.2mm_M2_ISO7380_Pad
J1: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J2: Conn_01x04; PinSocket_1x04_P2.54mm_Vertical_SMD_Pin1Left
L1: 6.5u; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
Q7: Q_PMOS_DGS; SOT-23
R1, R8, R9, R10: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2: 75k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R4: 40.2k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R5: 13k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R6, R7: 220; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R11: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: Rotary_Encoder_Switch; EC11_Rotary_Encoder
U1: AP65111AWU; TSOT-23-6
U3: ATtiny404-SS; SOIC-14_3.9x8.7mm_P1.27mm
U5: ADS7029; VSSOP-8_2.3x2mm_P0.5mm

Connections:
+3.3VA: C5.1, L1.2, Q7.1 (D), R4.1, R10.1
+3.3VP: D2.2 (A), J1.3, Q7.2 (G), R11.1
+3V3: C6.1, C9.1, D2.1 (K), J2.2, Q7.3 (S), R6.1, R7.1, R8.1, R9.1, U3.1 (VCC), U5.7 (AVDD); also elsewhere on the board
+BATT: BAT+1.1, C1.1, U1.1 (IN); also elsewhere on the board
/BAT_VOL: U3.2 (PA4); also elsewhere on the board
/CLK: R6.2, SW1.A, U3.6 (PB3)
/DT: R7.2, SW1.B, U3.7 (PB2)
/SCL: J2.3, R8.2, U3.9 (PB0)
/SCLK: U3.13 (PA3), U5.2 (SCLK)
/SDA: J2.4, R9.2, U3.8 (PB1)
/SWITCH: SW1.S1, U3.5 (PA7)
/TEMP: U3.3 (PA5); also elsewhere on the board
/TRIGGER: R1.1, U3.4 (PA6); also elsewhere on the board
/UDPI: J1.2, U3.10 (~RESET~/PA0)
/WELD+: U5.6 (AINP); also elsewhere on the board
/WELD-: U5.5 (AINM); also elsewhere on the board
/WELD_ADC: U3.12 (PA2), U5.3 (SDO)
/WELD_CS: U3.11 (PA1), U5.4 (~CS)
GND: BAT-1.1, C1.2, C6.2, C9.2, D1.1 (K), D3.1 (K), J1.1, J2.1, R5.2, R11.2, SW1.C, SW1.S2, U1.2 (GND), U3.14 (GND), U5.8 (GND); also elsewhere on the board
unnamed: C4.1, U1.4 (BST)
unnamed: C4.2, L1.1, U1.3 (SW)
unnamed: C5.2, R2.1, R4.2, R5.1
unnamed: D1.2 (A), R10.2
unnamed: D3.2 (A), R1.2
unnamed: R2.2, U1.6 (FB)

Notes on the sheet:
Power input
MCU
Display
Programming
Status LED
Encoder
ADC
DC Rating of inductor should be 25% higher than max current load
The P-MOS is open until USB voltage is present. USB voltage then shuts off normal supply. Programming then uses regulated USB voltage

Parts:
C7, C8, C12: 1n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D5, D6, D7: BZX84C3V3; SOT-23
Q1, Q2, Q3, Q4, Q5, Q6: PSMN0R9-30YLD; LFPAK56
R12, R14, R23: 5k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R13, R22, R24: 1k8; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R15, R17, R18, R19, R20, R21: 82R; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R16: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
TH1: 100k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U4: FAN3111E; SOT-23-5_HandSoldering

Connections:
+3V3: R16.2, U4.4; also elsewhere on the board
+BATT: R12.1, R14.1, U4.1; also elsewhere on the board
/BAT_VOL: C12.1, D5.1 (K), R12.2, R13.1; also elsewhere on the board
/TEMP: R16.1, TH1.2; also elsewhere on the board
/TRIGGER: U4.3; also elsewhere on the board
/WELD+: C7.1, D6.1 (K), R14.2, R22.1; also elsewhere on the board
/WELD-: C8.1, D7.1 (K), R23.2, R24.1; also elsewhere on the board
/Welding/G: R15.2, R17.2, R18.2, R19.2, R20.2, R21.2, U4.5
/Welding/OUT-: Q1.5 (D), Q2.5 (D), Q3.5 (D), Q4.5 (D), Q5.5 (D), Q6.5 (D), R23.1
GND: C7.2, C8.2, C12.2, D5.2 (A), D6.2 (A), D7.2 (A), Q1.1 (S), Q1.2 (S), Q1.3 (S), Q2.1 (S), Q2.2 (S), Q2.3 (S), Q3.1 (S), Q3.2 (S), Q3.3 (S), Q4.1 (S), Q4.2 (S), Q4.3 (S), Q5.1 (S), Q5.2 (S), Q5.3 (S), Q6.1 (S), Q6.2 (S), Q6.3 (S), R13.2, R22.2, R24.2, TH1.1, U4.2; also elsewhere on the board
unnamed: Q1.4 (G), R15.1
unnamed: Q2.4 (G), R17.1
unnamed: Q3.4 (G), R18.1
unnamed: Q4.4 (G), R19.1
unnamed: Q5.4 (G), R20.1
unnamed: Q6.4 (G), R21.1

Board: 2 copper layers, 80.0 x 35.0 mm, 57 parts (13 on the bottom side), 33 nets.

## Commit log

2020-10-16 initial commit of µSpot V1
2021-02-28 Layout finish
2021-02-28 Changes FAN3111 footprint and removed 5V
2021-02-28 Updated board layout
